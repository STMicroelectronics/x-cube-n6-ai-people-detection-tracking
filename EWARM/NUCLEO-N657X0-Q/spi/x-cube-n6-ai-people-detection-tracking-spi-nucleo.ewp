# IAR project x-cube-n6-ai-people-detection-tracking-spi-nucleo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32N6570-DK ST STM32N6570-DK
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: STM32N657xx; USE_FULL_ASSERT; USE_FULL_LL_DRIVER; VECT_TAB_SRAM; USE_IMX335_SENSOR; USE_VD66GY_SENSOR; USE_VD55G1_SENSOR; USE_VD1943_SENSOR; STM32N6570_NUCLEO_REV; TX_MAX_PARALLEL_NETWORKS=1; LL_ATON_PLATFORM=LL_ATON_PLAT_STM32N6; LL_ATON_OSAL=LL_ATON_OSAL_FREERTOS; LL_ATON_RT_MODE=LL_ATON_RT_ASYNC; LL_ATON_SW_FALLBACK; LL_ATON_DBG_BUFFER_INFO_EXCLUDED=1; APP_HAS_PARALLEL_NETWORKS=0; FEAT_FREERTOS; SCR_LIB_USE_SPI; SCR_LIB_USE_FREERTOS
  ICCARM.CCIncludePath2: ..\..\..\Inc; ..\..\..\Model\NUCLEO-N657X0-Q; ..\..\..\STM32Cube_FW_N6\Drivers\STM32N6xx_HAL_Driver\Inc; ..\..\..\STM32Cube_FW_N6\Drivers\STM32N6xx_HAL_Driver\Inc\Legacy; ..\..\..\STM32Cube_FW_N6\Drivers\CMSIS\Device\ST\STM32N6xx\Include; ..\..\..\STM32Cube_FW_N6\Drivers\CMSIS\Include; ..\..\..\STM32Cube_FW_N6\Drivers\CMSIS\DSP\Include; ..\..\..\STM32Cube_FW_N6\Drivers\BSP\Components\Common; ..\..\..\STM32Cube_FW_N6\Drivers\BSP\STM32N6xx_Nucleo; ..\..\..\STM32Cube_FW_N6\Utilities\lcd; ..\..\..\Lib\AI_Runtime\Inc; ..\..\..\Lib\AI_Runtime\Npu\ll_aton; ..\..\..\Lib\AI_Runtime\Npu\Devices\STM32N6xx; ..\..\..\Lib\lib_vision_models_pp\lib_vision_models_pp\Inc; ..\..\..\Lib\ai-postprocessing-wrapper; ..\..\..\Lib\Camera_Middleware; ..\..\..\Lib\Camera_Middleware\sensors; ..\..\..\Lib\Camera_Middleware\sensors\imx335; ..\..\..\Lib\Camera_Middleware\sensors\vd55g1; ..\..\..\Lib\Camera_Middleware\sensors\vd6g; ..\..\..\Lib\Camera_Middleware\sensors\vd1943; ..\..\..\Lib\Camera_Middleware\ISP_Library\isp\Inc; ..\..\..\Lib\Camera_Middleware\ISP_Library\evision\Inc; ..\..\..\Lib\FreeRTOS\Source\include; ..\..\..\Lib\FreeRTOS\Source\portable\GCC\ARM_CM55_NTZ\non_secure; ..\..\..\Lib\screenl\Inc; ..\..\..\Lib\screenl\ili9341
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: x-cube-n6-ai-people-detection-tracking-spi-nucleo.bin
  ILINK.IlinkOutputFile: x-cube-n6-ai-people-detection-tracking-spi-nucleo.out
  ILINK.IlinkIcfFile: stm32n657xx_axisram.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\Lib\AI_Runtime\Lib\ABI2.1\ARMCortexM55\NetworkRuntime1100_CM55_IAR.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM/Src
    ../../Src/: console.c freertos_libc.c startup_stm32n657xx.s
  group Lib/ai-postprocessing-wrapper
    ../../../Lib/ai-postprocessing-wrapper/: app_postprocess_fd_blazeface_ui.c app_postprocess_fd_yunet_ui.c app_postprocess_iseg_yolo_v8_ui.c app_postprocess_mpe_pd_uf.c app_postprocess_mpe_yolo_v8_uf.c app_postprocess_mpe_yolo_v8_ui.c app_postprocess_od_blazeface_uf.c app_postprocess_od_blazeface_ui.c app_postprocess_od_blazeface_uu.c app_postprocess_od_st_ssd_uf.c app_postprocess_od_st_yolox_uf.c app_postprocess_od_st_yolox_ui.c app_postprocess_od_yolov2_uf.c app_postprocess_od_yolov2_ui.c app_postprocess_od_yolov5_uu.c app_postprocess_od_yolov8_uf.c app_postprocess_od_yolov8_ui.c app_postprocess_spe_movenet_uf.c app_postprocess_spe_movenet_ui.c app_postprocess_sseg_deeplab_v3_uf.c app_postprocess_sseg_deeplab_v3_ui.c app_postprocess_template.c
  group Lib/AI_Runtime/Npu/Devices/STM32N6xx
    ../../../Lib/AI_Runtime/Npu/Devices/STM32N6xx/: mcu_cache.c npu_cache.c
  group Lib/AI_Runtime/Npu/ll_aton
    ../../../Lib/AI_Runtime/Npu/ll_aton/: ecloader.c ll_aton.c ll_aton_cipher.c ll_aton_debug.c ll_aton_lib.c ll_aton_lib_sw_operators.c ll_aton_osal_freertos.c ll_aton_rt_main.c ll_aton_runtime.c ll_aton_stai_internal.c ll_aton_util.c ll_sw_float.c ll_sw_integer.c
  group Lib/Camera_Middleware
    ../../../Lib/Camera_Middleware/: cmw_camera.c cmw_utils.c
  group Lib/Camera_Middleware/ISP_Library/isp/Src
    ../../../Lib/Camera_Middleware/ISP_Library/isp/Src/: isp_ae_algo.c isp_algo.c isp_awb_algo.c isp_cmd_parser.c isp_core.c isp_services.c isp_tool_com.c
  group Lib/Camera_Middleware/sensors
    ../../../Lib/Camera_Middleware/sensors/: cmw_imx335.c cmw_vd1943.c cmw_vd55g1.c cmw_vd66gy.c
  group Lib/Camera_Middleware/sensors/imx335
    ../../../Lib/Camera_Middleware/sensors/imx335/: imx335.c imx335_reg.c
  group Lib/Camera_Middleware/sensors/vd1943
    ../../../Lib/Camera_Middleware/sensors/vd1943/: vd1943.c
  group Lib/Camera_Middleware/sensors/vd55g1
    ../../../Lib/Camera_Middleware/sensors/vd55g1/: vd55g1.c
  group Lib/Camera_Middleware/sensors/vd6g
    ../../../Lib/Camera_Middleware/sensors/vd6g/: vd6g.c
  group Lib/FreeRTOS/Source
    ../../../Lib/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Lib/FreeRTOS/Source/portable/IAR/ARM_CM55_NTZ/non_secure
    ../../../Lib/FreeRTOS/Source/portable/IAR/ARM_CM55_NTZ/non_secure/: port.c portasm.s
  group Lib/lib_vision_models_pp/lib_vision_models_pp/Src
    ../../../Lib/lib_vision_models_pp/lib_vision_models_pp/Src/: od_pp_st_yolox.c od_pp_yolov2.c od_pp_yolov5.c od_pp_yolov8.c vision_models_pp.c vision_models_pp_maxi_if32.c vision_models_pp_maxi_is8.c vision_models_pp_maxi_iu8.c
  group Lib/screenl/ili9341
    ../../../Lib/screenl/ili9341/: ili9341.c ili9341_reg.c
  group Lib/screenl/Src
    ../../../Lib/screenl/Src/: scrl_common.c scrl_spi.c
  group Model/NUCLEO-N657X0-Q
    ../../../Model/NUCLEO-N657X0-Q/: network.c stai_network.c
  group Src
    ../../../Src/: app.c app_cam.c app_fuseprogramming.c freertos_bsp.c main.c stm32_lcd_ex.c stm32n6xx_it.c utils.c
  group STM32Cube_FW_N6/Drivers/BSP/Components/mx25um51245g
    ../../../STM32Cube_FW_N6/Drivers/BSP/Components/mx25um51245g/: mx25um51245g.c
  group STM32Cube_FW_N6/Drivers/BSP/STM32N6xx_Nucleo
    ../../../STM32Cube_FW_N6/Drivers/BSP/STM32N6xx_Nucleo/: stm32n6xx_nucleo.c stm32n6xx_nucleo_bus.c stm32n6xx_nucleo_xspi.c
  group STM32Cube_FW_N6/Drivers/CMSIS/Device/ST/STM32N6xx/Source/Templates
    ../../../STM32Cube_FW_N6/Drivers/CMSIS/Device/ST/STM32N6xx/Source/Templates/: system_stm32n6xx_fsbl.c
  group STM32Cube_FW_N6/Drivers/STM32N6xx_HAL_Driver/Src
    ../../../STM32Cube_FW_N6/Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_bsec.c stm32n6xx_hal_cacheaxi.c stm32n6xx_hal_cortex.c stm32n6xx_hal_dcmipp.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma2d.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_exti.c stm32n6xx_hal_gpio.c stm32n6xx_hal_i2c.c stm32n6xx_hal_i2c_ex.c stm32n6xx_hal_ltdc.c stm32n6xx_hal_ltdc_ex.c stm32n6xx_hal_pcd.c stm32n6xx_hal_pcd_ex.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_ramcfg.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_rif.c stm32n6xx_hal_spi.c stm32n6xx_hal_tim.c stm32n6xx_hal_uart.c stm32n6xx_hal_xspi.c stm32n6xx_ll_usb.c
  group STM32Cube_FW_N6/Utilities/lcd
    ../../../STM32Cube_FW_N6/Utilities/lcd/: stm32_lcd.c
